## config/boards/shields/NUMBSTONE/Kconfig.shield
```kconfig
if SHIELD_NUMBSTONE

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "NUMBSTONE"

endif
```
